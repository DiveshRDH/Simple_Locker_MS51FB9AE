# Keil uVision project Locker.uvgui.RDH.uvproj, settings and files
target Target 1 (MCS-51)
  device: MS51FB9AE Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x3FFF)  XRAM(0 - 0x3FF) CLOCK(24000000)
  output: Hii +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library\Device\Include;.\Library\StdDriver\inc
  group Source Group 1
    ./: main.c STARTUP.A51
  group Library
    ./Library/StdDriver/src/: common.c delay.c
